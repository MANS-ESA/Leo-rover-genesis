Commit message: feat: fix NAN

File: URDF/leo_sim.urdf (robot description, URDF)
Before this commit: robot leo_sim, 11 links, 10 joints
Links:
- removed link base_footprint
Joints:
- removed joint base_joint
